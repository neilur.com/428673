Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: Project Number
Time: 2023-03-06T09:13:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20211019_1515(x64) - Exporter 20.2.60.15 - Alternate UI 20.2.60.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 06 09:13:16 2023 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\eb9423d5-a0a8-4b32-8477-8f93ccb0ed8e\cd96969f-a449-475e-952b-dcc9e3a4fb62\ifc * Database version: 5507 * Database creation date: Mon Mar 06 09:13:16 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 06 09:13:16 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 06 09:13:16 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Awaiting Approval

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding, n/a
LongName: n/a
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
In: n/a
LongName: Level 0; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels

# IfcFlowTerminal: DBLTD_Neilur_ShowerTrays_900:900mm x 1200mm Shower Tray with Waste, 16
In: Level 0
Type - PredefinedType: SHOWER; Classification: D2010710 Showers (Uniformat); Material: DBLTD_Neilur_SolidSurface_White
Type - Pset_SanitaryTerminalTypeBath - NominalLength: 1200 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeBidet - NominalLength: 1200 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeSanitaryFountain - NominalLength: 1200 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeShower - NominalLength: 1200 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeSink - NominalLength: 1200 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeToiletPan - NominalLength: 1200 mm; NominalWidth: 900 mm
Type - Pset_SanitaryTerminalTypeUrinal - NominalLength: 1200 mm; NominalWidth: 900 mm
Type - Pset_SanitaryTerminalTypeWashHandBasin - NominalLength: 1200 mm; NominalWidth: 900 mm; Color: White
Pset_DistributionFlowElementCommon - Reference: 900mm x 1200mm Shower Tray with Waste; sets with these values: 2
Pset_ElementShading - Color: White
Pset_ManufacturerTypeInformation - ModelReference: 900mm x 1200mm Shower Tray with Waste; Manufacturer: Neilur
Pset_ProductRequirements - Category: Plumbing Fixtures

# IfcFlowTerminal: DBLTD_Neilur_ShowerTrays_900:900mm x 1400mm Shower Tray with Waste, 17
In: Level 0
Type - PredefinedType: SHOWER; Classification: D2010710 Showers (Uniformat); Material: DBLTD_Neilur_SolidSurface_White
Type - Pset_SanitaryTerminalTypeBath - NominalLength: 1400 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeBidet - NominalLength: 1400 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeSanitaryFountain - NominalLength: 1400 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeShower - NominalLength: 1400 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeSink - NominalLength: 1400 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeToiletPan - NominalLength: 1400 mm; NominalWidth: 900 mm
Type - Pset_SanitaryTerminalTypeUrinal - NominalLength: 1400 mm; NominalWidth: 900 mm
Type - Pset_SanitaryTerminalTypeWashHandBasin - NominalLength: 1400 mm; NominalWidth: 900 mm; Color: White
Pset_DistributionFlowElementCommon - Reference: 900mm x 1400mm Shower Tray with Waste; sets with these values: 2
Pset_ElementShading - Color: White
Pset_ManufacturerTypeInformation - ModelReference: 900mm x 1400mm Shower Tray with Waste; Manufacturer: Neilur
Pset_ProductRequirements - Category: Plumbing Fixtures

# IfcFlowTerminal: DBLTD_Neilur_ShowerTrays_900:900mm x 1600mm Shower Tray with Waste, 18
In: Level 0
Type - PredefinedType: SHOWER; Classification: D2010710 Showers (Uniformat); Material: DBLTD_Neilur_SolidSurface_White
Type - Pset_SanitaryTerminalTypeBath - NominalLength: 1600 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeBidet - NominalLength: 1600 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeSanitaryFountain - NominalLength: 1600 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeShower - NominalLength: 1600 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeSink - NominalLength: 1600 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeToiletPan - NominalLength: 1600 mm; NominalWidth: 900 mm
Type - Pset_SanitaryTerminalTypeUrinal - NominalLength: 1600 mm; NominalWidth: 900 mm
Type - Pset_SanitaryTerminalTypeWashHandBasin - NominalLength: 1600 mm; NominalWidth: 900 mm; Color: White
Pset_DistributionFlowElementCommon - Reference: 900mm x 1600mm Shower Tray with Waste; sets with these values: 2
Pset_ElementShading - Color: White
Pset_ManufacturerTypeInformation - ModelReference: 900mm x 1600mm Shower Tray with Waste; Manufacturer: Neilur
Pset_ProductRequirements - Category: Plumbing Fixtures

# IfcFlowTerminal: DBLTD_Neilur_ShowerTrays_900:900mm x 900mm Shower Tray with Waste, 15
In: Level 0
Type - PredefinedType: SHOWER; Classification: D2010710 Showers (Uniformat); Material: DBLTD_Neilur_SolidSurface_White
Type - Pset_SanitaryTerminalTypeBath - NominalLength: 900 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeBidet - NominalLength: 900 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeSanitaryFountain - NominalLength: 900 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeShower - NominalLength: 900 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeSink - NominalLength: 900 mm; NominalWidth: 900 mm; Color: White
Type - Pset_SanitaryTerminalTypeToiletPan - NominalLength: 900 mm; NominalWidth: 900 mm
Type - Pset_SanitaryTerminalTypeUrinal - NominalLength: 900 mm; NominalWidth: 900 mm
Type - Pset_SanitaryTerminalTypeWashHandBasin - NominalLength: 900 mm; NominalWidth: 900 mm; Color: White
Pset_DistributionFlowElementCommon - Reference: 900mm x 900mm Shower Tray with Waste; sets with these values: 2
Pset_ElementShading - Color: White
Pset_ManufacturerTypeInformation - ModelReference: 900mm x 900mm Shower Tray with Waste; Manufacturer: Neilur
Pset_ProductRequirements - Category: Plumbing Fixtures
